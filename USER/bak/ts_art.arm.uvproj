# Keil uVision project ts_art.arm.uvproj, settings and files
target MassageChair (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Linz +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\CM3;..\CMSIS\CM3\CORE;..\CMSIS\CM3\STARTUP;..\CMSIS\STM32LIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\USB\USBLIB\inc;..\USB\Mass_Storage\inc;..\HARDWARE;..\HARDWARE\LED;..\HARDWARE\nrf24l01;..\HARDWARE\signal;..\HARDWARE\spi;..\SYSTEM\signal
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../CMSIS/CM3/CORE/: core_cm3.c
    ../CMSIS/CM3/STARTUP/: startup_stm32f10x_hd.s
    ../CMSIS/CM3/: stm32f10x_it.c system_stm32f10x.c
    ../CMSIS/STM32LIB/src/: stm32f10x_spi.c stm32f10x_tim.c
  group FWLIB
    ../CMSIS/STM32LIB/src/: misc.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/signal/: signal.c
  group USBLIB
    ../USB/USBLIB/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USBConfig
    ../USB/Mass_Storage/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group USER
    ./: main.c platform.c transmitter.c ds311x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/nrf24l01/: nrf24L01.c
    ../HARDWARE/spi/: spi.c
